# Keil uVision project DM_Motor.uvprojx, settings and files
target DM_Motor (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") CLOCK(12000000) ESEL ELITTLE
  output: DM_Motor
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx
  c include: ..\..\RoboMaster\RM-CUBEMX\DM_Motor\Core\Inc;..\..\RoboMaster\RM-CUBEMX\DM_Motor\Drivers\STM32H7xx_HAL_Driver\Inc;..\..\RoboMaster\RM-CUBEMX\DM_Motor\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy;..\..\RoboMaster\RM-CUBEMX\DM_Motor\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\..\RoboMaster\RM-CUBEMX\DM_Motor\Drivers\CMSIS\Include;.cmsis\include;..\..\RoboMaster\RM-CUBEMX\DM_Motor\MDK-ARM\RTE\_DM_Motor;BSP;ReadMe;Device
  asm define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x20000
  group BSP
    BSP/: bsp_can.c
  group DEVICE
    Device/: DM_Motor.c
  group Drivers/CMSIS
    ../../RoboMaster/RM-CUBEMX/DM_Motor/Core/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../RoboMaster/RM-CUBEMX/DM_Motor/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c
  group Application/User/Core
    ../../RoboMaster/RM-CUBEMX/DM_Motor/Core/Src/: main.c gpio.c fdcan.c memorymap.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/MDK-ARM
    ../../RoboMaster/RM-CUBEMX/DM_Motor/MDK-ARM/: startup_stm32h723xx.s
